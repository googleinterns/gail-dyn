Commit message: minor fix bullet hopper

File: my_pybullet_envs/assets/plane.urdf (robot description, URDF)
Before this commit: robot plane, 1 links, 0 joints
Links:
- link planeLink: geometry collision box size=300 10 10; visual mesh filename=plane.obj scale=1 1 1
